DESCRIPTION = "My custom core package group"

inherit packagegroup

RDEPENDS:${PN} = "copy-ssh-key sudo"