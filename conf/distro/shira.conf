## conf/distro/shira.conf
```bitbake
DISTRO          = "shira"
DISTRO_NAME     = "Shira (Tutorial Distribution)"
DISTRO_VERSION  = "1.0"
```
